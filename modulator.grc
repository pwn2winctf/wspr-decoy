options:
  parameters:
    generate_options: no_gui
    id: modulator
    output_language: python
    run_options: run
    title: Modulator
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*3.14159265358979323846*1.4648/samp_rate
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(1.4648*samp_rate)
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: (0, 1, 2, 1, 0, -1, -2, -1, 0)
  states: {}
- name: freq
  id: parameter
  parameters:
    label: freq
    type: eng_float
    value: '7040100'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    bw0: 1e3
    freq0: freq
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', osmosdr_sink_0, '0']
- [blocks_repeat_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
